v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmos_cs.sym} 1990 -1370 0 0 {name=x2}
C {nmos_diff_amp.sym} 2420 -1370 0 0 {name=x4}
C {pmos_cs.sym} 1990 -1510 0 0 {name=x1}
C {devices/lab_pin.sym} 2140 -1540 0 1 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2570 -1520 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2140 -1520 0 1 {name=p3 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 2140 -1500 0 1 {name=p4 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 2140 -1480 0 1 {name=p5 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 2140 -1400 0 1 {name=p6 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 2140 -1380 0 1 {name=p7 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 2140 -1360 0 1 {name=p8 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 2140 -1340 0 1 {name=p9 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2570 -1350 0 1 {name=p10 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2570 -1540 0 1 {name=p11 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 2570 -1500 0 1 {name=p12 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 2570 -1390 0 1 {name=p13 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 2570 -1480 0 1 {name=p14 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 2570 -1370 0 1 {name=p15 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 2270 -1540 0 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 2270 -1520 0 0 {name=p17 sig_type=std_logic lab=VIP}
C {pmos_diff_amp.sym} 2420 -1510 0 0 {name=x3}
C {devices/iopin.sym} 1760 -1530 0 1 {name=p18 lab=VDD}
C {devices/iopin.sym} 1760 -1490 0 1 {name=p19 lab=GND}
C {devices/iopin.sym} 1760 -1450 0 1 {name=p20 lab=OUT}
C {devices/iopin.sym} 1760 -1420 0 1 {name=p21 lab=RS}
C {devices/ipin.sym} 1760 -1390 0 0 {name=p22 lab=VIN}
C {devices/ipin.sym} 1760 -1360 0 0 {name=p23 lab=VIP}
